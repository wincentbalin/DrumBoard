# IAR project TouchDemo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2013 MSP430F2013
  General.GStackSize2: 50
  General.GHeapSize2: 0
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2013.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    BoardDocumentation/: Measure_VLO_SW.s43 msp430_Day_4_Key_Demo ver0-09.c
